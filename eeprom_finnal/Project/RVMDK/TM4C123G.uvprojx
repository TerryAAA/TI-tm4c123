# Keil uVision project TM4C123G.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TM4C123G +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  c misc: --c99
  c include: ..\..\Libraries\inc;..\..\Libraries\utils;..\..\Libraries\driverlib;..\..\User;..\..\Mycode\led;..\..\Mycode\timerc;..\..\Mycode\schedule;..\..\Mycode\pwmc;..\..\Mycode\uartc;..\..\Mycode\lcd;..\..\Mycode\key;..\..\Mycode\ui;..\..\Mycode\isr;..\..\Mycode\flash
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Libraries
    ../../Libraries/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group User
    ../../User/: main.c startup_rvmdk.S
  group Mycode
    ../../Mycode/led/: led.c
    ../../Mycode/timerc/: timerc.c
    ../../Mycode/schedule/: schedule.c
    ../../Mycode/pwmc/: pwmc.c
    ../../Mycode/uartc/: uartc.c
    ../../Mycode/lcd/: lcdc.c
    ../../Mycode/key/: key.c
    ../../Mycode/ui/: ui.c
    ../../Mycode/isr/: isr.c
    ../../Mycode/flash/: eflash.c
  group Doc
    ../../Doc/: readme.md
software components: CMSIS:CORE 5.2.0
